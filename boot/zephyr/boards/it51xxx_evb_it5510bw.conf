## boot/zephyr/boards/it51xxx_evb_it5510bw.conf
```kconfig
CONFIG_USB_DEVICE_STACK_NEXT=y
CONFIG_USB_DEVICE_REMOTE_WAKEUP=n
CONFIG_BOOT_PREFER_SWAP_MOVE=y
```
